# Keil uVision project logistic.uvprojx, settings and files
target LOGISTIC (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: logistic
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\app;..\bsp\inc;..\CORE;..\STM32F10x_FWLib\inc;..\uC-CPU;..\uC-CPU\ARM-Cortex-M3;..\uC-LIB\Ports;..\uC-LIB;..\uCOS-II;..\uCOS-II\Ports;..\uCOS-II\Source;..\driver\inc;..\net\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../app/: main.c stm32f10x_it.c system_stm32f10x.c
  group BSP
    ../bsp/src/: bsp.c led.c usart.c usart3.c usart2.c
  group DRIVER
    ../driver/scr/: gps.c gprs.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uC-CPU
    ../uC-CPU/ARM-Cortex-M3/: cpu_a.asm cpu_c.c
  group uC-LIB
    ../uC-LIB/: lib_mem.c lib_str.c
    ../uC-LIB/Ports/: lib_mem_a.asm
  group uCOS-II
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group DOC
    ../: readme.txt
